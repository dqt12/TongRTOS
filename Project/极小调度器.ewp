# IAR project 极小调度器.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x20
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\; ..\FWlib\inc; ..\FWlib\src; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 极小调度器.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLIB
    ../FWlib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c
  group USER
    ../USER/: led.c main.c stm8s_interruput.c uart.c
