<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6781;&#x5C0F;&#x8C03;&#x5eA6;&#x5668;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


